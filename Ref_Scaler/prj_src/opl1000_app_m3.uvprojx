# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APP (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ MBEDTLS_CONFIG_FILE="<config-opl-mini.h>" HTTPCLIENT_SSL_ENABLE
  c misc: --preinclude=sys_common.h
  c include: .\inc;.\inc\ble;.\inc\cmsis;.\inc\freertos;.\inc\mw_ota;.\inc\lwip;.\inc\wpa_supplicant;.\inc\mw_fim;.\inc\lwip\arch;.\inc\lwip\lwip;.\inc\at;.\inc\wifi;.\inc\wifi\rom_if;.\inc\wifi\utils;.\inc\sys;.\inc\sys\include;.\inc\sys\startup;.\inc\sys\boot_sequence;.\inc\hal;.\inc\hal\hal_auxadc;.\inc\hal\hal_system;.\inc\hal\hal_vic;.\inc\hal\hal_dbg_uart;.\inc\hal\hal_tick;.\inc\aliyun\config;.\inc\aliyun\iotx-sdk-c\include;.\blewifi;.\inc\hal\hal_pwm;.\inc\mbedtls\include\mbedtls;.\inc\mbedtls\include;.\inc\mbedtls\configs;.\inc\mbedtls\port\include;.\inc\hal\securityipdriver;.\inc\lwip\lwip\src\include\lwip;.\inc\lwip\lwip\src\include\lwip\prot;.\scaler;.\inc\lwip\lwip\src\include;.\inc\lwip\ports\freertos\include;.\inc\lwip\lwip\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --diag_suppress=L6305
  group source
    ./: main_patch.c mqtt-example.c
  group blewifi
    ./blewifi/: blewifi_app.c blewifi_common.c blewifi_ctrl.c blewifi_data.c blewifi_server_app.c blewifi_server_app_gatt.c blewifi_ctrl_http_ota.c blewifi_http_ota.c blewifi_ble_api.c blewifi_wifi_api.c
  group object
    ./lib/: opl1000_patch_m3.lib opl1000_sdk_m3.lib symdefs.o
  group scaler
    ./scaler/: ftoa_util.c scaler_common.c scaler_data.c scaler_data_task.c scaler_notify.c scaler_polling.c scaler_sys.c scaler_profile.c sntp_time.c
